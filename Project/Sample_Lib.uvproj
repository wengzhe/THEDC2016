# Keil uVision project Sample_Lib.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Sample_Lib
  c flags: Optim=1 oTime=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\STM32F10x_StdPeriph_Driver\inc;..\System;..\User;..\Driver;..\Calc;..\Exec
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group startup
    ./: startup_stm32f10x_hd.s
  group Strategy
    ../User/: main.c
  group System
    ../System/: stm32f10x_it.c system_stm32f10x.c sysconfig.c
  group STM32F1Lib
    ../STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_adc.c misc.c stm32f10x_dma.c
  group Driver
    ../Driver/: PWM.C Driver.c ADC.c UART.C IMU.c
  group Calc
    ../Calc/: TONE.C Calc.c Speed.c COM.C Angle.c
  group Exec
    ../Exec/: MUSIC.C Exec.c Musics.c POINTS.C
